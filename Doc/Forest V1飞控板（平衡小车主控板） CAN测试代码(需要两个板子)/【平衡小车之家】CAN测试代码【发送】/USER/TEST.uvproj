# Keil uVision project TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MPU6050_Lib\inc;..\SYSTEM\TIMER;..\USER;..\MPU6050_Lib\IIC;..\MPU6050_Lib\MPU6050;..\SYSTEM\LED;..\SYSTEM;..\SYSTEM\OLED;..\SYSTEM\ADC;..\SYSTEM\MiniBalance;..\SYSTEM\filter;..\SYSTEM\datascope;..\SYSTEM\CAN
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: STM32F10x.s
  group SYSTEM
    ./: test.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/LED/: led.c
    ../SYSTEM/OLED/: oled.c
    ../SYSTEM/CAN/: can.c
